<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Low_Power_Demo.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>ksdk_platform_lib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ksdk_platform_lib</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>Low_Power_Demo</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Low_Power_Demo</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>ksdk_platform_lib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Low_Power_Demo</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Release</name>
            <member>
                <project>ksdk_platform_lib</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>Low_Power_Demo</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>

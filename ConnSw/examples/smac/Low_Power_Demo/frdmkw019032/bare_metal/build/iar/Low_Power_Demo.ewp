# IAR project Low_Power_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW01Z128xxx4 Freescale MKW01Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW01Z128CHN4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../../app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK13_FWK513_PATH_$/platform/CMSIS/Include; ../../../../../../../boards/frdmkw019032; $_KSDK13_FWK513_PATH_$/platform/devices; $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/include; $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/startup; $_KSDK13_FWK513_PATH_$/platform/system/src/clock/MKW01Z4; $_KSDK13_FWK513_PATH_$/platform/devices; $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/startup; ../../../../../../../framework/GPIOIrq; ../../../../../../../framework/LowPower/Interface/KW0xZ; ../../../../../../../framework/LowPower/Interface/KW0xZ; ../../../../../../../framework/LowPower/Source/KW0xZ; ../../../../../../../framework/Keyboard/Interface; ../../../../../../../framework/LED/Interface; ../../../../../../../framework/SerialManager/Source/SPI_Adapter; ../../../../../../../ieee_802_15_4/Source/SMAC/Generic; ../../../../../../../ieee_802_15_4/Source/SMAC/Interface; ../../../../../../../ieee_802_15_4/Source/SMAC/Source; ../../../../../../../ieee_802_15_4/Source/Phy/Interface; ../../../../../../../framework/Common; ../../../../../../../framework/Flash/Internal; $_KSDK13_FWK513_PATH_$/platform/drivers/src/flash/C90TFS/drvsrc/include; ../../../../../../../framework/MemManager/Interface; ../../../../../../../framework/Messaging/Interface; ../../../../../../../framework/OSAbstraction/Interface; $_KSDK13_FWK513_PATH_$/platform/osa/inc; ../../../../../../../framework/Panic/Interface; ../../../../../../../framework/RNG/Interface; ../../../../../../../framework/SerialManager/Interface; ../../../../../../../framework/TimersManager/Interface; ../../../../../../../framework/TimersManager/Source; ../../../../../../../framework/FunctionLib; ../../../../../../../framework/Lists; ../../../../../../../framework/SecLib; ../../../../../../../framework/ModuleInfo; ../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x; ../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x/SX123xDrv; ../../../../../../../ieee_802_15_4/Source/Phy/Source/XcvrSpi; ../../../../common; ../../../common; $_KSDK13_FWK513_PATH_$/platform/drivers/inc; $_KSDK13_FWK513_PATH_$/platform/system/inc; $_KSDK13_FWK513_PATH_$/platform/hal/inc; $_KSDK13_FWK513_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: Low_Power_Demo_BM.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../../platform/devices/MKW01Z4/linker/iar/MKW01Z128xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK513_PATH_$\lib\ksdk_platform_lib\iar\KW01Z4\debug\libksdk_platform.a; ../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW01Z128CHN4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK513_PATH_$\lib\ksdk_platform_lib\iar\KW01Z4\release\libksdk_platform.a; ../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a
  group framework/Common
    ../../../../../../../framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/Flash/Internal
    ../../../../../../../../KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../../../framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
    ../../../../../../../../KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group framework/FunctionLib
    ../../../../../../../framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    ../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    ../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    ../../../../../../../framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../framework/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../framework/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../framework/Lists/: GenericList.c GenericList.h
  group framework/LowPower/Interface
    ../../../../../../../framework/LowPower/Interface/KW0xZ/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../framework/LowPower/Source/KW0xZ/: PWR.c PWR_Platform.c PWR_Platform.h PWRLib.c PWRLib.h
  group framework/MemManager/Interface
    ../../../../../../../framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    ../../../../../../../framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    ../../../../../../../framework/OSAbstraction/Source/: fsl_osa_ext_bm.c
  group framework/Panic/Interface
    ../../../../../../../framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../../../framework/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../framework/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../../../framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../../../framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/TimersManager/Interface
    ../../../../../../../framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group ieee_802.15.4/PHY/Interface
    ../../../../../../../ieee_802_15_4/Source/Phy/Interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/PHY/Source/MKW0x
    ../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x/: ASP.c Phy.h PhyDebug.c PhyExtended.c PhyExtended.h PhyISR.c PhyISR.h PhyPacketProcessor.c PhyPib.c PhyPib.h PhyPlmeData.c PhyStateMachine.c PhyTime.c PhyTime.h
  group ieee_802.15.4/PHY/Source/MKW0x/SX123xDrv
    ../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x/SX123xDrv/: SX123xDrv.c SX123xDrv.h SX123xReg.h SX123xReg32MHz.h
  group ieee_802.15.4/PHY/Source/XcvrSPI
    ../../../../../../../ieee_802_15_4/Source/Phy/Source/XcvrSpi/: SPI.c SPI.h
  group ieee_802.15.4/SMAC/Generic
    ../../../../../../../ieee_802_15_4/Source/SMAC/Generic/: SMAC_Channels.h SMAC_Config.h
  group ieee_802.15.4/SMAC/Interface
    ../../../../../../../ieee_802_15_4/Source/SMAC/Interface/: SMAC_Interface.h
  group ieee_802.15.4/SMAC/Source
    ../../../../../../../ieee_802_15_4/Source/SMAC/Source/: SMAC.c SMAC.h
  group Interface
    ../../../common/: Application_Interface.h
  group KSDK
    ../../../../../../../boards/frdmkw019032/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group RTOS/Startup
    ../../../../../../../../KSDK_1.3.0/platform/devices/: startup.c startup.h
    ../../../../../../../../KSDK_1.3.0/platform/devices/MKW01Z4/startup/iar/: startup_MKW01Z4.s
    ../../../../../../../../KSDK_1.3.0/platform/devices/MKW01Z4/startup/: system_MKW01Z4.c system_MKW01Z4.h
  group Source
    ../../: app_preinclude.h
    ../../../common/: Low_Power_DemoApp.c Low_Power_DemoMenus.c Low_Power_DemoMenus.h
